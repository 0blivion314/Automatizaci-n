# Repository 0blivion314/Automatizaci-n

File README.md:

Proyecto: Automatizaación Bluetooth.
Alumnos: Alliana Facundo, Astorga Agustín.
Profesor: Martin Leguizamon.
*Descripción del proyecto:
Este sistema de automatización,controlado por Bluetooth,vamos a tener la posibilidad de controlar 3 relays mediante un celular o dispositivo capaz de descargar una aplicación de control. Contamos con un ESP32 para realizar la conexión entre el dispositivo y este, y así enviar las señales correspondientes para activar los relays. 

*Material/componentes:
Relays X3
borneras 3x1, 2x1.
Componentes electrónicos (rectificadores x3, transistores x3, resistencias x9, capacitores x5, reguladores de voltaje X2, botones x2, esp32, pineras)
Alimentación: fuente de 12v, fuente de 5v.
Leds 9v, placa cobre doble faz, estaño, flux.

Costo aproximado: $20.000

*Tiempos: 
Diseño placa, esquemático: 1 semanas.
Armado PCB: 1 mes.
Programación: 1 semanas.

## KiCad design kickad/automatizacion wifi/automatizacion wifi.kicad_pcb

Board: 2 copper layers, 68.5 x 131.7 mm, 43 parts (5 on the bottom side), 39 nets.

Parts:
5v1: LM7805_TO220; TO-220-2
C2, C3, C4: C; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5, C6: 100uf; CP_Radial_D8.0mm_P3.80mm
D1, D2, D3: DIODE; D_SMA
J1: Conn_02x02_Counter_Clockwise; PinHeader_2x02_P2.54mm_Vertical
J2, J3, J4: Screw_Terminal_01x03; TerminalBlock_bornier-3_P5.08mm
J6: Conn_01x04_Pin; PinSocket_1x04_P2.54mm_Vertical
K1, K2, K3: RELAY_C; Relay_C
Q1, Q2, Q3: 2N3904; P200_SOT-23
R1, R2, R3, R4, R5, R6, R7, R8, R9: R; R_0805
R10, R11, R12: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R13, R14: 470; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1, SW2: SW_Push; SW_SPST_B3U-1000P-B
U1, U2, U3: PC817; DIP-4_W7.62mm
U4: ESP32-WROOM-32E__4MB_; ESP32-WROOM-32E
U5: NCP1117-1.5_SOT223; SOT-223-3_TabPin2
bornera1: bornera; BORNERA2_AZUL
bornera2: bornera; TerminalBlock_bornier-2_P5.08mm

Connections:
/3.3V: C3.2, C4.1, R10.1, R11.1, U4.2 (3V3), U5.2 (VO)
/5V: 5v1.2 (GND), 5v1.3 (VO), C5.2, C6.1, C6.2, D1.2 (K), D2.2 (K), D3.2 (K), J1.1, J1.2, K1.2, K2.2, K3.2, Q1.1 (E), Q2.1 (E), Q3.1 (E), R2.2, R5.2, R8.2, bornera1.1
/5VES: C2.1, J1.4, J6.1, U5.3 (VI), bornera2.2
/C1: J2.2, K3.1
/C2: J3.2, K1.1
/C3: J4.2, K2.1
/EN: R12.2, U4.3 (EN)
/FLASH: R11.2, R13.1, U4.25 (IO0)
/GNDE: C2.2, C3.1, C4.2, J1.3, J6.2, SW1.1, SW2.1, U1.2, U2.2, U3.2, U4.1 (GND), U4.15 (GND), U4.38 (GND), U5.1 (GND), bornera2.1
/NC1: J2.3, K3.4
/NC2: J3.3, K1.4
/NC3: J4.3, K2.4
/NO1: J2.1, K3.3
/NO2: J3.1, K1.3
/NO3: J4.1, K2.3
/R1: R7.1, U4.24 (IO2)
/R2: R1.1, U4.11 (IO26)
/R3: R4.1, U4.12 (IO27)
/RX: J6.3, U4.34 (RXD0)
/SWITCH: R10.2, R12.1, R14.1
/TX: J6.4, U4.35 (TXD0)
/VIN: 5v1.1 (VI), C5.1, bornera1.2
unnamed: D1.1 (A), K1.5, Q1.3 (C)
unnamed: D2.1 (A), K2.5, Q2.3 (C)
unnamed: D3.1 (A), K3.5, Q3.3 (C)
unnamed: Q1.2 (B), R3.2
unnamed: Q2.2 (B), R6.2
unnamed: Q3.2 (B), R9.2
unnamed: R1.2, U1.1
unnamed: R2.1, U1.4
unnamed: R3.1, U1.3
unnamed: R4.2, U2.1
unnamed: R5.1, U2.4
unnamed: R6.1, U2.3
unnamed: R7.2, U3.1
unnamed: R8.1, U3.4
unnamed: R9.1, U3.3
unnamed: R13.2, SW2.2
unnamed: R14.2, SW1.2

## Commit log

2024-11-14 README.md
2024-11-20 Create Codigo
